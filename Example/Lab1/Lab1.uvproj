# Keil uVision project Lab1.uvproj, settings and files
target Lab1 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Lab1 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS\stm_lib\inc;.\CMSIS\cmsis_boot;.\CMSIS\cmsis_core
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./: startup_stm32f0xx.s main.c
  group CMSIS
    ./CMSIS/stm_lib/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_tim.c
    ./CMSIS/cmsis_core/: core_cm0.c
    ./CMSIS/cmsis_boot/: system_stm32f0xx.c
