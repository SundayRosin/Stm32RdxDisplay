# Keil uVision project RDX0154.uvproj, settings and files
target DISP (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: RDX0154 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS\STM32F0xx_StdPeriph_Driver\inc;.\CMSIS\STM32F0xx_StdPeriph_Driver\inc;.\CMSIS\CMSIS\cmsis_boot;.\CMSIS\CMSIS\cmsis_core;.\CMSIS\CMSIS\stm_lib\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./: startup_stm32f0xx.s main.c i2c.c display.c initIO.c
  group CMSIS
    ./CMSIS/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_rcc.c stm32f0xx_gpio.c stm32f0xx_usart.c stm32f0xx_i2c.c
    ./CMSIS/CMSIS/cmsis_boot/: system_stm32f0xx.c
