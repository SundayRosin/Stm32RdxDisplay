# Keil uVision project RDX0154.uvproj, settings and files
target DISP (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: RDX0154 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\Lib\CMSIS\Include;.\Lib\STM32F0xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./: startup_stm32f0xx.s main.c i2c.c display.c initIO.c functions.c
    ./Lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_i2c.c
  group CMSIS
    ./Lib/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group one_wire
    ./Lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_gpio.c stm32f0xx_dma.c
    ./onewire_usart/: onewire_usart.c onewire_usart.h
