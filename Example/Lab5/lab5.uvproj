# Keil uVision project lab5.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: lab5 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\Lib\STM32F0xx_StdPeriph_Driver\inc;.\display;.\IO;.\Lib\CMSIS\Include;.\Lib\CMSIS\Device\ST\STM32F0xx\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./: startup_stm32f0xx.s main.c
  group CMSIS
    ./Lib/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ./Lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c
  group Other
    ./display/: display.c i2c.c
    ./IO/: initIO.c
    ./: functions.c
  group ADC
    ./: adc.c
